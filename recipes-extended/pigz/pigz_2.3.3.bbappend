SRC_URI = "http://zlib.net/${BPN}/fossils/${BP}.tar.gz"
SRC_URI += "file://link-order.patch"
