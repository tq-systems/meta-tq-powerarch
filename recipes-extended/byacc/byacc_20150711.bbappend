SRC_URI = "https://www.mirrorservice.org/sites/lynx.invisible-island.net/byacc/byacc-20150711.tgz \
           file://byacc-open.patch"
