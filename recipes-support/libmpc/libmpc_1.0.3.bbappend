SRC_URI = "https://ftp.gnu.org/gnu/mpc/mpc-${PV}.tar.gz"
