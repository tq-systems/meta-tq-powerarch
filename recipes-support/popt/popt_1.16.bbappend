SRC_URI = "https://fossies.org/linux/misc/popt-1.16.tar.gz \
           file://pkgconfig_fix.patch \
           file://popt_fix_for_automake-1.12.patch \
           file://disable_tests.patch \
          "
