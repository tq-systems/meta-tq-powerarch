SRC_URI = "http://nwl.cc/pub/cryptodev-linux/cryptodev-linux-1.7.tar.gz"
